# Keil uVision project gr_Appli.uvprojx, settings and files
target gr_Appli (6140001::V6.14.1::ARMCLANG)
  device: STM32N647X0HxQ STMicroelectronics
  pack: Keil.STM32N6xx_DFP.1.0.0
  cpu: IRAM(0x34080000-0x341FFFFF) IROM(0x34000400-0x3407FFFF) CLOCK(8000000) FPU3(DFPU) CPUTYPE("Cortex-M55") ELITTLE TZ DSP
  output: gr_Appli +hex
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32N647xx
  c include: ../../Appli/Core/Inc;../../Secure_nsclib;D:/modify_project/STM32Cube_FW_N6_V1.0.0/Drivers/STM32N6xx_HAL_Driver/Inc;D:/modify_project/STM32Cube_FW_N6_V1.0.0/Drivers/CMSIS/Device/ST/STM32N6xx/Include;D:/modify_project/STM32Cube_FW_N6_V1.0.0/Drivers/STM32N6xx_HAL_Driver/Inc/Legacy;D:/modify_project/STM32Cube_FW_N6_V1.0.0/Drivers/CMSIS/Include;..\..\..\..\Drivers\BSP
  memory RVCT4: ROM 0x34000400 size 0x7fc00
  memory RVCT9: RAM 0x34080000 size 0x180000
  scatter file: stm32n647xx_LRUN.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
  group Application/MDK-ARM
    ../: startup_stm32n647xx.c
  group Application/User/Appli/Core
    ../../Appli/Core/Src/: main.c stm32n6xx_it.c stm32n6xx_hal_msp.c secure_nsc.c
  group Drivers/STM32N6xx_HAL_Driver
    D:/modify_project/STM32Cube_FW_N6_V1.0.0/Drivers/STM32N6xx_HAL_Driver/Src/: stm32n6xx_hal_cortex.c stm32n6xx_hal_rcc.c stm32n6xx_hal_rcc_ex.c stm32n6xx_hal_gpio.c stm32n6xx_hal_dma.c stm32n6xx_hal_dma_ex.c stm32n6xx_hal_pwr.c stm32n6xx_hal_pwr_ex.c stm32n6xx_hal.c stm32n6xx_hal_exti.c stm32n6xx_hal_dcmipp.c stm32n6xx_hal_dma2d.c stm32n6xx_hal_i2c.c stm32n6xx_hal_i2c_ex.c stm32n6xx_hal_ltdc.c stm32n6xx_hal_ltdc_ex.c stm32n6xx_hal_rif.c stm32n6xx_hal_sd.c stm32n6xx_hal_sd_ex.c stm32n6xx_ll_sdmmc.c stm32n6xx_hal_mmc.c stm32n6xx_hal_mmc_ex.c stm32n6xx_hal_sdio.c stm32n6xx_hal_tim.c stm32n6xx_hal_tim_ex.c stm32n6xx_hal_uart.c stm32n6xx_hal_uart_ex.c stm32n6xx_hal_xspi.c
  group Drivers/CMSIS
    ../../Appli/Core/Src/: system_stm32n6xx_s.c
  group Drivers/BSP/AP3216C
    ../../../../Drivers/BSP/AP3216C/: ap3216c.c
software components: CMSIS:CORE 5.6.0
